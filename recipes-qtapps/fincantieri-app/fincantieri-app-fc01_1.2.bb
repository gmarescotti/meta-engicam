VERSION="1.2"

PR="r3"

FCMODEL="fc01"

include generic.inc


VERSION="1.2"

PR="r1"

FCMODEL="fc02"

include generic.inc

